Properties of the parts of a building model (IFC2X3)

# File
Description: IFC2X3
File name: DRACO_80.100_VÁLVULA_MICTÓRIOSENSORIZADA_PÓLUX_PAREDE.IFC
Time: 2023-06-13T20:27:58
Written by: SwIFC
Made in: SolidWorks 2022

# IfcSite, Default Site
RefLatitude: 0, 0, 0, 0; RefLongitude: 0, 0, 0, 0; RefElevation: 0 m

# IfcBuildingStorey, Default Storey
In: Default Building
Elevation: 0 m

# IfcBuildingElementProxy: DRACO_80.100_VÁLVULA_MICTÓRIOSENSORIZADA_PÓLUX_PAREDE
In: Default Storey
Material: Steel
